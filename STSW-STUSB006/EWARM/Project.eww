<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\NVM_Flasher_STM32F072RB.ewp</path>
  </project>
  <batchBuild />
</workspace>
